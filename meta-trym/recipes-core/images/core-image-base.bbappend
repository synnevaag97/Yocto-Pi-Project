#IMAGE_INSTALL:append = "xkeyboard-config"
CORE_IMAGE_EXTRA_INSTALL += "vim"
